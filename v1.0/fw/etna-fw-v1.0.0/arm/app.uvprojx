# Keil uVision project app.uvprojx, settings and files
target etna (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: probe-fw +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52 CONFIG_NFCT_PINS_AS_GPIOS ARM_MATH_CM4
  c include: ..\;..\components\nrf5_sdk;..\components\nrf5_sdk\ble\ble_advertising;..\components\nrf5_sdk\ble\ble_dtm;..\components\nrf5_sdk\ble\ble_racp;..\components\nrf5_sdk\ble\ble_services\ble_ancs_c;..\components\nrf5_sdk\ble\ble_services\ble_ans_c;..\components\nrf5_sdk\ble\ble_services\ble_bas;..\components\nrf5_sdk\ble\ble_services\ble_bas_c;..\components\nrf5_sdk\ble\ble_services\ble_cscs;..\components\nrf5_sdk\ble\ble_services\ble_cts_c;..\components\nrf5_sdk\ble\ble_services\ble_dfu;..\components\nrf5_sdk\ble\ble_services\ble_dis;..\components\nrf5_sdk\ble\ble_services\ble_gls;..\components\nrf5_sdk\ble\ble_services\ble_hids;..\components\nrf5_sdk\ble\ble_services\ble_hrs;..\components\nrf5_sdk\ble\ble_services\ble_hrs_c;..\components\nrf5_sdk\ble\ble_services\ble_hts;..\components\nrf5_sdk\ble\ble_services\ble_ias;..\components\nrf5_sdk\ble\ble_services\ble_ias_c;..\components\nrf5_sdk\ble\ble_services\ble_lbs;..\components\nrf5_sdk\ble\ble_services\ble_lbs_c;..\components\nrf5_sdk\ble\ble_services\ble_lls;..\components\nrf5_sdk\\ble\ble_services\ble_nus;..\components\nrf5_sdk\ble\ble_services\ble_nus_c;..\components\nrf5_sdk\ble\ble_services\ble_rscs;..\components\nrf5_sdk\ble\ble_services\ble_rscs_c;..\components\nrf5_sdk\ble\ble_services\ble_tps;..\components\nrf5_sdk\ble\common;..\components\nrf5_sdk\ble\nrf_ble_gatt;..\components\nrf5_sdk\ble\nrf_ble_qwr;..\components\nrf5_sdk\ble\peer_manager;..\components\nrf5_sdk\boards;..\components\nrf5_sdk\drivers_nrf\adc;..\components\nrf5_sdk\drivers_nrf\clock;..\components\nrf5_sdk\drivers_nrf\common;..\components\nrf5_sdk\drivers_nrf\comp;..\components\nrf5_sdk\drivers_nrf\delay;..\components\nrf5_sdk\drivers_nrf\gpiote;..\components\nrf5_sdk\drivers_nrf\hal;..\components\nrf5_sdk\drivers_nrf\i2s;..\components\nrf5_sdk\drivers_nrf\lpcomp;..\components\nrf5_sdk\drivers_nrf\pdm;..\components\nrf5_sdk\drivers_nrf\power;..\components\nrf5_sdk\drivers_nrf\ppi;..\components\nrf5_sdk\drivers_nrf\pwm;..\components\nrf5_sdk\drivers_nrf\qdec;..\components\nrf5_sdk\drivers_nrf\rng;..\components\nrf5_sdk\drivers_nrf\rtc;..\components\nrf5_sdk\drivers_nrf\saadc;..\components\nrf5_sdk\drivers_nrf\spi_master;..\components\nrf5_sdk\drivers_nrf\spi_slave;..\components\nrf5_sdk\drivers_nrf\swi;..\components\nrf5_sdk\drivers_nrf\timer;..\components\nrf5_sdk\drivers_nrf\twi_master;..\components\nrf5_sdk\drivers_nrf\twis_slave;..\components\nrf5_sdk\drivers_nrf\uart;..\components\nrf5_sdk\drivers_nrf\usbd;..\components\nrf5_sdk\drivers_nrf\wdt;..\components\nrf5_sdk\libraries\bsp;..\components\nrf5_sdk\libraries\button;..\components\nrf5_sdk\libraries\crc16;..\components\nrf5_sdk\libraries\crc32;..\components\nrf5_sdk\libraries\csense;..\components\nrf5_sdk\libraries\csense_drv;..\components\nrf5_sdk\libraries\experimental_section_vars;..\components\nrf5_sdk\libraries\fds;..\components\nrf5_sdk\libraries\fstorage;..\components\nrf5_sdk\libraries\gpiote;..\components\nrf5_sdk\libraries\hardfault;..\components\nrf5_sdk\libraries\hci;..\components\nrf5_sdk\libraries\led_softblink;..\components\nrf5_sdk\libraries\log;..\components\nrf5_sdk\libraries\log\src;..\components\nrf5_sdk\libraries\low_power_pwm;..\components\nrf5_sdk\libraries\mem_manager;..\components\nrf5_sdk\libraries\pwm;..\components\nrf5_sdk\libraries\queue;..\components\nrf5_sdk\libraries\scheduler;..\components\nrf5_sdk\libraries\sensorsim;..\components\nrf5_sdk\libraries\slip;..\components\nrf5_sdk\libraries\timer;..\components\nrf5_sdk\libraries\twi;..\components\nrf5_sdk\libraries\uart;..\components\nrf5_sdk\libraries\usbd;..\components\nrf5_sdk\libraries\usbd\class\audio;..\components\nrf5_sdk\libraries\usbd\class\cdc;..\components\nrf5_sdk\libraries\usbd\class\cdc\acm;..\components\nrf5_sdk\libraries\usbd\class\hid;..\components\nrf5_sdk\libraries\usbd\class\hid\generic;..\components\nrf5_sdk\libraries\usbd\class\hid\kbd;..\components\nrf5_sdk\libraries\usbd\class\hid\mouse;..\components\nrf5_sdk\libraries\usbd\class\msc;..\components\nrf5_sdk\libraries\usbd\config;..\components\nrf5_sdk\libraries\util;..\components\nrf5_sdk\softdevice\common\softdevice_handler;..\components\nrf5_sdk\softdevice\s132\headers;..\components\nrf5_sdk\softdevice\s132\headers\nrf52;..\components\nrf5_sdk\toolchain;..\components\nrf5_sdk\external\segger_rtt;..\main;..\components\nrf5_sdk\drivers_nrf\uart;..\components\nrf5_sdk\libraries\uart;..\components\nrf5_sdk\libraries\fifo;..\components\irobot\include;..\components;..\components\decawave;..\components\ads1118\include
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52
  asm include: ..\..\..\config\ble_app_hrs_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002c48 size 0xd3b8
  group app
    ../main/: main.c
  group config
    ../main/: hw_config.h app_config.h sdk_config.h
  group ads1118
    ../components/ads1118/: ads1118.c ads1118_hal.c
  group board
    ../components/nrf5_sdk/boards/: boards.c
  group bsp
    ../components/nrf5_sdk/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group ble
    ../components/nrf5_sdk/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/nrf5_sdk/ble/ble_advertising/: ble_advertising.c
    ../components/nrf5_sdk/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../components/nrf5_sdk/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group ble_services
    ../components/nrf5_sdk/ble/ble_services/ble_bas/: ble_bas.c
    ../components/nrf5_sdk/ble/ble_services/ble_dis/: ble_dis.c
    ../main/: ble_xpr.c
  group nrf_drivers
    ../components/nrf5_sdk/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/nrf5_sdk/drivers_nrf/common/: nrf_drv_common.c
    ../components/nrf5_sdk/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/nrf5_sdk/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/nrf5_sdk/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../components/nrf5_sdk/drivers_nrf/hal/: nrf_saadc.c
    ../components/nrf5_sdk/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../components/nrf5_sdk/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../components/nrf5_sdk/drivers_nrf/timer/: nrf_drv_timer.c
  group nrf_libs
    ../components/nrf5_sdk/libraries/button/: app_button.c
    ../components/nrf5_sdk/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../components/nrf5_sdk/libraries/timer/: app_timer.c
    ../components/nrf5_sdk/libraries/crc16/: crc16.c
    ../components/nrf5_sdk/libraries/fds/: fds.c
    ../components/nrf5_sdk/libraries/fstorage/: fstorage.c
    ../components/nrf5_sdk/libraries/hardfault/: hardfault_implementation.c
    ../components/nrf5_sdk/libraries/sensorsim/: sensorsim.c
    ../components/nrf5_sdk/libraries/uart/: app_uart_fifo.c
    ../components/nrf5_sdk/libraries/fifo/: app_fifo.c
  group log
    ../components/nrf5_sdk/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group segger
    ../components/nrf5_sdk/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group softdevice
    ../components/nrf5_sdk/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_hrs_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002c38 size 0xd3c8
software components: CMSIS:CORE 5.1.1, CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.11.1, Device:Startup 8.16.0
